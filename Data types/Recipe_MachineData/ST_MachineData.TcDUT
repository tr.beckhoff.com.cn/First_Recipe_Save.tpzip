TYPE ST_MachineData :		(*机器参数, 只保存一个文件*)
STRUCT
	MacData1		: ARRAY[1..2] OF LREAL;
	MacData2		: ARRAY[1..2] OF INT;
	MacData3		: ARRAY[1..2] OF BOOL;

END_STRUCT
END_TYPE
