TYPE ST_RecData :			(*配方参数, 不同配方参数, 保存在不同的文件中*)
STRUCT

(*设置参数*)
	rTemp:REAL:=120;      	(*温度，120.C*)
	rSpeedRpm:REAL:=3000;(*速度，3000rpm*)
	rPressure:REAL:=9.8; (*压力，9.8kg*)

END_STRUCT
END_TYPE
